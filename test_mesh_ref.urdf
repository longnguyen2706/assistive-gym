Commit message: legs and hips joint working

File: test_mesh_ref.urdf (robot description, URDF)
Before this commit: robot human, 97 links, 96 joints
Joints:
- joint left_toe: parent left_foot_limb -> left_foot_rzdammy
- joint right_toe: parent right_foot_limb -> right_foot_rzdammy
